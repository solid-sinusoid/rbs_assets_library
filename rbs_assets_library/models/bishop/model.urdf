Commit message: add new meshes and refactor code that generates models by mesh files

File: rbs_assets_library/models/bishop/model.urdf (robot description, URDF)
Before this commit: robot bishop, 1 links, 0 joints
Links:
- link body: mass 0.0001101962500190503 -> 0.019284343753333807
